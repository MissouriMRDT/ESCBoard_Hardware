.title KiCad schematic
IC1 +5V H2_LOW +3V3 TC2117
C4 +3V3 H2_LOW 2.2u
C7 +3V3 H2_LOW 100u
Conn1 H2_LOW VDD Pack Voltage
C3 VDD H2_LOW 10u,50V
C5 VDD H2_LOW 10u,50V
C9 VDD H2_LOW 10u,50V
C10 VDD H2_LOW 15u,100V
C6 VDD H2_LOW 15u,100V
C8 VDD H2_LOW 10u,50V
U1 Net-_R15-Pad1_ Net-_C15-Pad1_ Net-_R11-Pad2_ NC_01 NC_02 FAULT Net-_R14-Pad1_ H2_LOW +3V3 H2_LOW Net-_C12-Pad1_ DC_CAL Net-_C13-Pad1_ Net-_C17-Pad1_ Net-_C17-Pad2_ EN_GATE H1 L1 H2 L2 H3 L3 Net-_C12-Pad1_ +3V3 BR_SO1 BR_SO2 Net-_C18-Pad1_ H2_LOW VDD Net-_C26-Pad1_ Net-_C26-Pad2_ Net-_C25-Pad1_ Net-_C25-Pad2_ H3_LOW M_L3 H3_VS M_H3 Net-_C23-Pad2_ H2_LOW M_L2 H2_VS M_H2 Net-_C22-Pad2_ H1_LOW M_L1 H1_VS M_H1 Net-_C21-Pad2_ Net-_R16-Pad2_ Net-_C19-Pad1_ Net-_C19-Pad1_ Net-_C19-Pad2_ VDD VDD NC_03 NC_04 H2_LOW DRV8302
C20 VDD H2_LOW 10u, 50V
C27 VDD H2_LOW 10u, 50V
C29 VDD H2_LOW 10u, 50V
R20 H2_LOW Net-_C26-Pad1_ 100K
R23 H1_LOW Net-_C26-Pad2_ 100K
R22 H2_LOW Net-_C25-Pad1_ 100K
R21 H3_LOW Net-_C25-Pad2_ 100K
C25 Net-_C25-Pad1_ Net-_C25-Pad2_ 2.2n
C18 Net-_C18-Pad1_ H2_LOW 2.2u
C23 H3_VS Net-_C23-Pad2_ 220n
C22 H2_VS Net-_C22-Pad2_ 220n
C21 H1_VS Net-_C21-Pad2_ 220n
R16 H2_LOW Net-_R16-Pad2_ 1M
C19 Net-_C19-Pad1_ Net-_C19-Pad2_ 100n
C24 H2_LOW VDD 10u,50V
L1 +5V Net-_C19-Pad1_ 22u
C28 +5V H2_LOW 100u
D5 Net-_C19-Pad1_ H2_LOW 60V,2A
C12 Net-_C12-Pad1_ H2_LOW 2.2u
C14 Net-_C12-Pad1_ H2_LOW 2.2u
C17 Net-_C17-Pad1_ Net-_C17-Pad2_ 22n
C13 Net-_C13-Pad1_ H2_LOW 2.2u
C16 Net-_C13-Pad1_ H2_LOW 2.2u
R14 Net-_R14-Pad1_ H2_LOW 10K
R13 Net-_R11-Pad2_ H2_LOW 3.3K
R11 +5V Net-_R11-Pad2_ 18K
R15 Net-_R15-Pad1_ H2_LOW 220K
R12 Net-_C15-Pad1_ Net-_C11-Pad1_ 15K
C11 Net-_C11-Pad1_ H2_LOW 6.8n
C15 Net-_C15-Pad1_ H2_LOW 120p
R17 SENSE3 H1_VS 39K
R26 H2_LOW SENSE3 2.2K
R18 SENSE2 H2_VS 39K
R27 H2_LOW SENSE2 2.2K
R19 SENSE1 H3_VS 39K
R28 H2_LOW SENSE1 2.2K
D2 +5V H2_LOW TVS_5V
C32 +3V3 H2_LOW 2.2u
C37 +3V3 H2_LOW 2.2u
C35 +3V3 H2_LOW 2.2u
C40 +3V3 H2_LOW 2.2u
C41 +3V3 H2_LOW 2.2u
C34 H2_LOW +3V3 2.2u
C36 +3V3 H2_LOW 2.2u
C30 H2_LOW Net-_C30-Pad2_ 2.2u
C31 H2_LOW Net-_C31-Pad2_ 2.2u
U2 +3V3 NC_05 NC_06 NC_07 Net-_C33-Pad1_ Net-_C38-Pad1_ Net-_C39-Pad1_ NC_08 NC_09 AN_IN NC_10 H2_LOW +3V3 SENSE3 SENSE2 SENSE1 ADC_TEMP H2_LOW +3V3 TX_SDA_NSS NC_11 NC_12 RX_SCL_MOSI LED_GREEN LED_RED BR_SO2 BR_SO1 NC_13 RX_SCL_MOSI TX_SDA_NSS Net-_C30-Pad2_ +3V3 DC_CAL L3 L2 L1 TX_SDA_NSS RX_SCL_MOSI NC_14 NC_15 H3 H2 H1 USB_DM USB_DP Net-_J3-Pad4_ Net-_C31-Pad2_ +3V3 Net-_J3-Pad2_ NC_16 EN_GATE NC_17 FAULT NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 H2_LOW NC_24 NC_25 H2_LOW +3V3 STM32F40X_LQFP64
C39 Net-_C39-Pad1_ H2_LOW 100n
C33 Net-_C33-Pad1_ H2_LOW 15p
C38 Net-_C38-Pad1_ H2_LOW 15p
X1 Net-_C33-Pad1_ Net-_C38-Pad1_ H2_LOW 8MHz, 10ppm
Q1 VDD Net-_Q1-Pad2_ H1_VS IRFS7530
Q3 VDD Net-_Q3-Pad2_ H2_VS IRFS7530
Q5 VDD Net-_Q5-Pad2_ H3_VS IRFS7530
Q2 H1_VS Net-_Q2-Pad2_ H1_LOW IRFS7530
Q4 H2_VS Net-_Q4-Pad2_ H2_LOW IRFS7530
Q6 H3_VS Net-_Q6-Pad2_ H3_LOW IRFS7530
R35 Net-_Q5-Pad2_ M_H3 4.7
R36 Net-_Q6-Pad2_ M_L3 4.7
R37 H3_LOW Net-_Q6-Pad2_ 39K
R33 Net-_Q4-Pad2_ M_L2 4.7
R32 Net-_Q3-Pad2_ M_H2 4.7
R29 Net-_Q1-Pad2_ M_H1 4.7
R30 Net-_Q2-Pad2_ M_L1 4.7
R31 H1_LOW Net-_Q2-Pad2_ 39K
R34 H1_LOW Net-_Q4-Pad2_ 39K
R3 +3V3 ADC_TEMP NTC 10K
R4 ADC_TEMP H2_LOW 10K
C1 ADC_TEMP H2_LOW 2.2u
Conn2 H2_LOW H1_VS Phase1
Conn3 H2_LOW H2_VS Phase2
Conn4 H2_LOW H3_VS Phase3
R24 H3_LOW H2_LOW 1m
R25 H1_LOW H2_LOW 1m
C26 Net-_C26-Pad1_ Net-_C26-Pad2_ 2.2n
R5 LED_RED Net-_D1-Pad2_ 100
R6 LED_GREEN Net-_D3-Pad2_ 100
R10 +3V3 Net-_D4-Pad2_ 2.2K
D1 H2_LOW Net-_D1-Pad2_ RED
D4 H2_LOW Net-_D4-Pad2_ GREEN
D3 H2_LOW Net-_D3-Pad2_ GREEN
R1 VDD AN_IN 39K
R2 AN_IN H2_LOW 2.2K
C2 AN_IN H2_LOW 100n
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ NC_26 H2_LOW H2_LOW USB_B_Mini
R9 USB_DM Net-_J1-Pad2_ 22
R8 Net-_J1-Pad3_ USB_DP 22
R7 +5V Net-_J1-Pad1_ 0
J2 RX_SCL_MOSI H2_LOW TX_SDA_NSS SERIAL PORT
J3 +3V3 Net-_J3-Pad2_ H2_LOW Net-_J3-Pad4_ Net-_C39-Pad1_ Programming
.end
